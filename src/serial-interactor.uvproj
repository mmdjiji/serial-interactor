# Keil uVision project serial-interactor.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F1K08S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: serial-interactor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c uart.c uart.h
